# Repository mattvenn/basic-ecp5-pcb

File README.md:

## ECP5 FPGA dev board

* Make an ECP5 FPGA dev board
* Keep it super simple and cheap
* Configured by on-board FLASH or direct with a Raspberry Pi
* 6 PMODs, 2 buttons, 2 LEDs, FLASH for configuration bitstreams.
* buttons are active low, LEDs are active low.

There is also an iCE40 version of this board: https://github.com/mattvenn/first-fpga-pcb

## What a Lattice ecp5 FPGA needs

Check ECP5 family datasheet for more information.

* A clock input. Has to be provided by an oscillator, it doesn't have a crystal driver. Has to go to a PCLK pad
* 1.1v core supply for the internal logic. Should supply at least 600mA
* 2.5v auxiliary power supply. Should supply 10mA
* 3.3v IO supply for the IO pins. In this design, all banks of IO have the same supply. Same PSU is used for all PMODs, and is rated at 1A.
* Get configured over SPI interface. This can be done directly by a microcontroller or a computer, or the bitstream can be programmed into some FLASH, and the FPGA will read it at boot. If FLASH isn't provided then the bitstream needs to be programmed at every power up or configuration reset. See sysconfig documentation for more info.
* Decoupling capacitors for each IO bank.

## PCB

* [Schematic](hardware/schematic.pdf)
* [OHSPark project](https://oshpark.com/shared_projects/pCsPoHNi) 
* [Gerbers](hardware/hardware/basic-ecp5-pcb-2020-07-20-fab.zip)

* 4 layer board stackup: signal, gnd, 3.3v, signal

## BOM

* FPGA ecp5 12k (LFE5U-12F-6BG256C) or 45k (LFE5U-45F-6BG256C) part, 14mm bga with 256 pins, 0.8mm pitch 
* 2 x TLV62568 DC/DC switchers for core (1.1v) and IO (3.3v).
* 2.5v reg TLV73325PDBVT
* 16MHz oscillator SIT2001BI-S2-33N-16.000000G
* 16MB FLASH W25Q128JVSIM (same as icebreaker)

## Design Review

* core supply (1.1v) is now DC/DC for 1A using TLV62568
* pmod and IO supply is now DC/DC for 1A using TLV62568
* move ferrite beads to input side of psu
* pullups on io2/3 of flash
* pulldown on tclk of jtag
* fix vias under bga by moving to 0.25mm drill 0.45mm annular ring
* add more ground vias under BGA

## Errata
* configuration bits for FPGA should be tied to gnd not through a 10k resistor. The voltage is about 1v, so might
  be a little close to the threshold of the 3.3v IOBANK supply. Replace with 0Ohm resistors? Or just tie to gnd?

## RPi connection info

See [test/mv_ecp.lpf](test/mv_ecp.lpf) for FPGA pinning. The following are the physical pins on the raspberry pi:

* serial: TX, RX on pins 8 and 10
* I2C: pins 2 and 3.  
* GPIOs: pins 31, 32, 33, 36.
* SPI: SDO, SDI, CLK, CE0 on pins 19, 21, 23, 24. These are connected to the onboard FLASH for bitstream config.
* Extra SPI CE1: pin 26 

### RPi Gotchas

* [fomu_flash will leave the SPI device in an unusable state](https://github.com/im-tomu/fomu-flash/issues/8). Run `sudo rmmod spi_bcm2835 && sudo modprobe spi_bcm2835` to reset it.

## Test: 

Simple [test](test/blinky.v) connects buttons to LEDs and toggles all other pins every second.

Yosys and NextPNR are used to create the bitstream and then it's copied to the Raspberry Pi specified
by PI_ADDR in the [Makefile](test/Makefile). 

[Fomu-Flash](https://github.com/im-tomu/fomu-flash) is used to flash the SPI memory. Clone the repo on the Pi and set
the path in the Makefile with FOMU_FLASH.

Run make in [./test](test) to build, copy and program the bitstream.

## PicoRV32 PicoSoC

I have adapted Claire Wolf's PicoRV32 Picosoc for this board: https://github.com/mattvenn/picorv32/tree/ecp5/picosoc

## Reference

* http://www.latticesemi.com/ecp5
* In particular, the ECP5 and ECP5-5G Hardware Checklist is very useful

## Inspiration

* https://github.com/Spritetm/hadbadge2019_pcb
* https://github.com/gregdavill/OrangeCrab
* https://www.crowdsupply.com/radiona/ulx3s

## Attribution

* ECP5 library part for Kicad created with https://github.com/xesscorp/KiCad-Schematic-Symbol-Libraries

## License

* Hardware is licensed under the [Permissive CERN open hardware license v2](cern_ohl_p_v2.txt)
* Software is licensed under the [GNU Lesser General Public License v2.1](LICENSE)
* Documentation is licensed under the [CCO](CC0_license)

# Open Source Hardware

This board is an OSHWA approved design: [ES000012](https://certification.oshwa.org/es000012.html)

## KiCad design hardware/basic-ecp5-pcb.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C8, C9, C10, C22: 100n; C_0805_2012Metric
C3, C20: 1u; C_0805_2012Metric
C7, C11, C15, C26: 10u; C_0805_2012Metric
C12, C13: 4.7u; C_0805_2012Metric
C14: 22u; C_0805_2012Metric
C21: CP; CP_Elec_5x5.4
D1, D3, D4, D5: LED; LED_0805_2012Metric
FB1, FB2, FB3: Ferrite_Bead_Small; L_0805_2012Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_01x02; PinHeader_2x01_P2.54mm_Vertical
J2, J9: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J3, J4, J5, J6, J7, J8: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal
L2, L3: 2.2uH; L_Taiyo-Yuden_NR-40xx
Q1: Q_NMOS_GSD; SOT-23
R1, R2: 4.7k; R_0805_2012Metric
R4: 100k; R_0805_2012Metric
R5: 120k; R_0805_2012Metric
R6, R9, R12, R13: 200R; R_0805_2012Metric
R7: 68k; R_0805_2012Metric
R8: 15k; R_0805_2012Metric
R10, R11: 10k; R_0805_2012Metric
SW1, SW2: SW_Push; SW_PUSH_6mm
TP1: 3.3v; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP3: 2.5v; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP5: clock; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP6: 1.1v; TestPoint_THTPad_D1.0mm_Drill0.5mm
U2: W25Q128JVSIM; SOIC-8_5.23x5.23mm_P1.27mm
U3, U4: TLV62568DBV; SOT-23-5
U5: TLV73325PDBV; SOT-23-5
X1: SiT2001B; SOT-23-5

Connections:
+1V1: C8.1, C9.1, C10.1, C11.1, C14.1, L2.2, R4.2, TP6.1; also elsewhere on the board
+2V5: C20.1, C22.1, C26.1, TP3.1, U5.5 (OUT); also elsewhere on the board
+3.3VP: C1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C15.1, D1.2 (A), J3.1, J3.2, J4.1, J4.2, J5.1, J5.2, J6.1, J6.2, J7.1, J7.2, J8.1, J8.2, L3.2, R1.1, R2.1, R7.2, R10.2, R11.2, R12.2, R13.2, TP1.1, U2.8 (VCC), X1.3, X1.4; also elsewhere on the board
+5V: C21.1, FB1.2, FB2.2, FB3.2, J1.1, J2.2, J2.4, J9.2, J9.4, R9.2
/gp0: J2.27, J9.27
/gp1: J2.28, J9.28
/gp4: J2.7, J9.7
/gp5: J2.29, J9.29
/gp18: J2.12, J9.12
/gp19: J2.35, J9.35
/gp20: J2.38, J9.38, R1.2
/gp21: J2.40, J9.40, R2.2
/gp22: J2.15, J9.15
/gp23: J2.16, J9.16
/gp26: J2.37, J9.37
/pi_3v3: J2.1, J9.1
/pi_3v3_2: J2.17, J9.17
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C20.2, C21.2, C22.2, C26.2, D3.1 (K), H1.1, H2.1, H3.1, H4.1, J1.2, J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, J3.3, J3.4, J4.3, J4.4, J5.3, J5.4, J6.3, J6.4, J7.3, J7.4, J8.3, J8.4, J9.6, J9.9, J9.14, J9.20, J9.25, J9.30, J9.34, J9.39, Q1.2 (S), R5.1, R8.1, SW1.2, SW2.2, U2.4 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), X1.1; also elsewhere on the board
unnamed: C3.1, FB3.1, U5.1 (IN), U5.3 (EN)
unnamed: C12.1, FB1.1, U3.1 (EN), U3.4 (VIN)
unnamed: C13.1, FB2.1, U4.1 (EN), U4.4 (VIN)
unnamed: D1.1 (K), R6.1
unnamed: D3.2 (A), R9.1
unnamed: D4.2 (A), R12.1
unnamed: D5.2 (A), R13.1
unnamed: L2.1, U3.3 (SW)
unnamed: L3.1, U4.3 (SW)
unnamed: Q1.3 (D), R6.2
unnamed: R4.1, R5.2, U3.5 (FB)
unnamed: R7.1, R8.2, U4.5 (FB)
button1: R10.1, SW1.1; also elsewhere on the board
button2: R11.1, SW2.1; also elsewhere on the board
cdone: J2.11, J9.11, Q1.1 (G); also elsewhere on the board
ce1: J2.26, J9.26; also elsewhere on the board
clk: TP5.1, X1.5; also elsewhere on the board
creset: J2.13, J9.13; also elsewhere on the board
gp6: J2.31, J9.31; also elsewhere on the board
gp12: J2.32, J9.32; also elsewhere on the board
gp13: J2.33, J9.33; also elsewhere on the board
gp14: J2.8, J9.8; also elsewhere on the board
gp15: J2.10, J9.10; also elsewhere on the board
gp16: J2.36, J9.36; also elsewhere on the board
led1: D4.1 (K); also elsewhere on the board
led2: D5.1 (K); also elsewhere on the board
p1_1: J3.11; also elsewhere on the board
p1_2: J3.9; also elsewhere on the board
p1_3: J3.7; also elsewhere on the board
p1_4: J3.5; also elsewhere on the board
p1_7: J3.12; also elsewhere on the board
p1_8: J3.10; also elsewhere on the board
p1_9: J3.8; also elsewhere on the board
p1_10: J3.6; also elsewhere on the board
p2_1: J4.11; also elsewhere on the board
p2_2: J4.9; also elsewhere on the board
p2_3: J4.7; also elsewhere on the board
p2_4: J4.5; also elsewhere on the board
p2_7: J4.12; also elsewhere on the board
p2_8: J4.10; also elsewhere on the board
p2_9: J4.8; also elsewhere on the board
p2_10: J4.6; also elsewhere on the board
p3_1: J5.11; also elsewhere on the board
p3_2: J5.9; also elsewhere on the board
p3_3: J5.7; also elsewhere on the board
p3_4: J5.5; also elsewhere on the board
p3_7: J5.12; also elsewhere on the board
p3_8: J5.10; also elsewhere on the board
p4_1: J6.11; also elsewhere on the board
p4_2: J6.9; also elsewhere on the board
p4_3: J6.7; also elsewhere on the board
p4_4: J6.5; also elsewhere on the board
p4_7: J6.12; also elsewhere on the board
p4_8: J6.10; also elsewhere on the board
p4_9: J6.8; also elsewhere on the board
p4_10: J6.6; also elsewhere on the board
p5_1: J7.11; also elsewhere on the board
p5_2: J7.9; also elsewhere on the board
p5_3: J7.7; also elsewhere on the board
p5_4: J7.5; also elsewhere on the board
p5_7: J7.12; also elsewhere on the board
p5_8: J7.10; also elsewhere on the board
p5_9: J7.8; also elsewhere on the board
p5_10: J7.6; also elsewhere on the board
p6_1: J8.11; also elsewhere on the board
p6_2: J8.9; also elsewhere on the board
p6_3: J8.7; also elsewhere on the board
p6_4: J8.5; also elsewhere on the board
p6_7: J8.12; also elsewhere on the board
p6_8: J8.10; also elsewhere on the board
p6_9: J8.8; also elsewhere on the board
p6_10: J8.6; also elsewhere on the board
sd_clk: J2.23, J9.23, U2.6 (CLK); also elsewhere on the board
sd_cs: J2.24, J9.24, U2.1 (~CS); also elsewhere on the board
sdi: J2.21, J9.21, U2.2 (DO(IO1)); also elsewhere on the board
sdo: J2.19, J9.19, U2.5 (DI(IO0)); also elsewhere on the board

Notes on the sheet:
1.1v @ 1A
Power Supply
Clock
FLASH
Peripherals
FPGA
Programming
16Mbyte FLASH supports 0Bh fast read. Same model as used in IceBreaker
FOMU pins
ce0
used for i2c
Extra RPi pins
another pi cs pin
2.5v @ 300mA
3.3v @ 1A
vout = 0.6 * (1 + R1/R2) vout = 3.32
vout = 0.6 * (1 + R1/R2) vout = 1.1
Duplicate port to expose all pins
CDONE
cdone can't drive an LED
Raspberry Pi Pinning

Parts:
J10: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
R3: 10k; R_0805_2012Metric
RN1, RN2: 10k; R_Array_Concave_4x0603
TP2, TP4, TP7: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm
U1: ECP5U_45_CABGA256; BGA-256_14.0x14.0mm_Layout16x16_P0.8mm_Ball0.45mm_Pad0.32mm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

Connections:
+1V1: U1.G6 (VCC[6]), U1.G7 (VCC[6]), U1.G9 (VCC[6]), U1.L8 (VCC[6]), U1.L9 (VCC[6]), U1.L10 (VCC[6]); also elsewhere on the board
+2V5: U1.G11 (VCCAUX[2]), U1.L7 (VCCAUX[2]); also elsewhere on the board
+3.3VP: J10.1, RN1.5 (R4.2), RN1.7 (R2.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), U1.F6 (VCCIO0[2]), U1.F7 (VCCIO0[2]), U1.F10 (VCCIO1[2]), U1.F11 (VCCIO1[2]), U1.H6 (VCCIO7[2]), U1.H7 (VCCIO7[2]), U1.H11 (VCCIO2[2]), U1.J6 (VCCIO6[2]), U1.J7 (VCCIO6[2]), U1.J11 (VCCIO2[2]), U1.K11 (VCCIO3[2]), U1.L6 (VCCIO8), U1.L11 (VCCIO3[2]); also elsewhere on the board
/fpga/cfg_0: RN1.1 (R1.1), TP2.1, U1.N10 (CFG_0)
/fpga/cfg_1: RN1.2 (R2.1), TP4.1, U1.P10 (CFG_1)
/fpga/cfg_2: RN1.3 (R3.1), TP7.1, U1.R10 (CFG_2)
/fpga/tck: J10.4, R3.2, U1.T10 (TCK)
/fpga/tdi: J10.8, U1.R11 (TDI)
/fpga/tdo: J10.6, U1.M10 (TDO)
/fpga/tms: J10.2, U1.T11 (TMS)
GND: J10.3, J10.5, J10.7, J10.9, R3.1, RN1.6 (R3.2), RN1.8 (R1.2), U1.A1 (GND[27]), U1.A16 (GND[27]), U1.D2 (GND[27]), U1.D15 (GND[27]), U1.F8 (GND[27]), U1.F9 (GND[27]), U1.G8 (GND[27]), U1.G10 (GND[27]), U1.H1 (GND[27]), U1.H8 (GND[27]), U1.H9 (GND[27]), U1.H10 (GND[27]), U1.H16 (GND[27]), U1.J8 (GND[27]), U1.J9 (GND[27]), U1.J10 (GND[27]), U1.K6 (GND[27]), U1.K7 (GND[27]), U1.K8 (GND[27]), U1.K9 (GND[27]), U1.K10 (GND[27]), U1.N2 (GND[27]), U1.N15 (GND[27]), U1.T1 (GND[27]), U1.T5 (GND[27]), U1.T12 (GND[27]), U1.T16 (GND[27]); also elsewhere on the board
button1: U1.R2 (PL59C/+/LDQ65); also elsewhere on the board
button2: U1.T2 (PL59D/-/LDQ65); also elsewhere on the board
cdone: U1.P9 (DONE); also elsewhere on the board
ce1: U1.T13 (PR65B/-/HS/RDQSN65); also elsewhere on the board
clk: U1.A7 (PT38A/+/PCLKT0_0); also elsewhere on the board
creset: J10.10, RN1.4 (R4.1), U1.R9 (PROGRAMN); also elsewhere on the board
gp6: U1.T6 (PB4A/+/D7/IO7); also elsewhere on the board
gp12: U1.R5 (PL65A/+/HS/LDQS65); also elsewhere on the board
gp13: U1.T4 (PL65B/-/HS/LDQSN65); also elsewhere on the board
gp14: U1.T15 (PR59D/-/RDQ65); also elsewhere on the board
gp15: U1.T14 (PR62D/-/RDQ65); also elsewhere on the board
gp16: U1.R4 (PL62C/+/LDQ65); also elsewhere on the board
led1: U1.R3 (PL62B/-/HS/LDQ65); also elsewhere on the board
led2: U1.T3 (PL62D/-/LDQ65); also elsewhere on the board
p1_1: U1.A8 (PT38B/-/PCLKC0_0); also elsewhere on the board
p1_2: U1.A10 (PT51B/-); also elsewhere on the board
p1_3: U1.A12 (PT71B/-); also elsewhere on the board
p1_4: U1.A14 (PT83B/-); also elsewhere on the board
p1_7: U1.A9 (PT51A/+); also elsewhere on the board
p1_8: U1.A11 (PT71A/+); also elsewhere on the board
p1_9: U1.A13 (PT83A/+); also elsewhere on the board
p1_10: U1.A15 (PT85B/-/URC_GPLL1C_IN); also elsewhere on the board
p2_1: U1.A2 (PT4A/+/ULC_GPLL1T_IN); also elsewhere on the board
p2_2: U1.B4 (PT11B/-); also elsewhere on the board
p2_3: U1.B5 (PT15B/-); also elsewhere on the board
p2_4: U1.B6 (PT31B/-); also elsewhere on the board
p2_7: U1.A3 (PT6A/+); also elsewhere on the board
p2_8: U1.A4 (PT6B/-); also elsewhere on the board
p2_9: U1.A5 (PT18A/+); also elsewhere on the board
p2_10: U1.A6 (PT18B/-); also elsewhere on the board
p3_1: U1.R1 (PL44B/-/VREF1_6/HS/LDQ41); also elsewhere on the board
p3_2: U1.N1 (PL41A/+/HS/LDQS41); also elsewhere on the board
p3_3: U1.L2 (PL35B/-/PCLKC6_1/HS/LDQ41); also elsewhere on the board
p3_4: U1.K1 (PL32C/+/PCLKT7_0/LDQ29); also elsewhere on the board
p3_7: U1.P1 (PL44A/+/HS/LDQ41); also elsewhere on the board
p3_8: U1.M1 (PL35C/+/PCLKT6_0/LDQ41); also elsewhere on the board
p4_1: U1.G1 (PL29A/+/GR_PCLK7_1/HS/LDQS29); also elsewhere on the board
p4_2: U1.E1 (PL20D/-/LDQ17); also elsewhere on the board
p4_3: U1.D1 (PL17A/+/HS/LDQS17); also elsewhere on the board
p4_4: U1.C2 (PL14B/-/HS/LDQ17); also elsewhere on the board
p4_7: U1.F1 (PL23A/+/HS/LDQ29); also elsewhere on the board
p4_8: U1.E2 (PL17B/-/HS/LDQSN17); also elsewhere on the board
p4_9: U1.C1 (PL14A/+/HS/LDQ17); also elsewhere on the board
p4_10: U1.B1 (PL11A/+/ULC_GPLL0T_IN/HS/LDQ17); also elsewhere on the board
p5_1: U1.B16 (PR11A/+/URC_GPLL0T_IN/HS/RDQ17); also elsewhere on the board
p5_2: U1.C16 (PR14A/+/HS/RDQ17); also elsewhere on the board
p5_3: U1.E16 (PR20D/-/RDQ17); also elsewhere on the board
p5_4: U1.F16 (PR23A/+/HS/RDQ29); also elsewhere on the board
p5_7: U1.C15 (PR14B/-/HS/RDQ17); also elsewhere on the board
p5_8: U1.D16 (PR17A/+/HS/RDQS17); also elsewhere on the board
p5_9: U1.E15 (PR17B/-/HS/RDQSN17); also elsewhere on the board
p5_10: U1.G16 (PR29A/+/GR_PCLK2_1/HS/RDQS29); also elsewhere on the board
p6_1: U1.J16 (PR32A/+/PCLKT2_1/HS/RDQ29); also elsewhere on the board
p6_2: U1.L16 (PR35A/+/PCLKT3_1/HS/RDQ41); also elsewhere on the board
p6_3: U1.M16 (PR35C/+/PCLKT3_0/RDQ41); also elsewhere on the board
p6_4: U1.P16 (PR44A/+/HS/RDQ41); also elsewhere on the board
p6_7: U1.K16 (PR32C/+/PCLKT2_0/RDQ29); also elsewhere on the board
p6_8: U1.L15 (PR35B/-/PCLKC3_1/HS/RDQ41); also elsewhere on the board
p6_9: U1.N16 (PR41A/+/HS/RDQS41); also elsewhere on the board
p6_10: U1.R16 (PR44B/-/VREF1_3/HS/RDQ41); also elsewhere on the board
sd_clk: RN2.2 (R2.1), U1.M5 (PL65C/+/LDQ65), U1.N9 (CCLK/MCLK/SCK); also elsewhere on the board
sd_cs: RN2.3 (R3.1), U1.N8 (PB15A/+/HOLDN/DI/BUSY/CSSPIN/CEN); also elsewhere on the board
sdi: U1.T7 (PB11A/+/D1/MISO/IO1); also elsewhere on the board
sdo: U1.T8 (PB11B/-/D0/MOSI/IO0); also elsewhere on the board

Notes on the sheet:
jtag arm 10 pin pinout
cfg[2:0] = 010. MSPI mode
JTAG
PSU
Config & SPI

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
Board: 4 copper layers, 100.0 x 68.0 mm, 71 parts (0 on the bottom side), 105 nets.

## Commit log

2020-07-15 ignore
2020-07-15 notes
2020-07-16 pmods connected and routed
2020-07-16 routed
2020-07-16 config added
2020-07-16 gerbers, readme, schematic
2020-07-16 remove test
2020-07-16 update page info
2020-07-17 changes for design review (see readme)
2020-07-17 tidying
2020-07-17 info on psus
2020-07-17 add serial connection
2020-07-17 updated gerbers
2020-07-17 updated schematic
2020-07-17 license
2020-07-17 Create LICENSE
2020-07-17 link license
2020-07-17 Rename LICENSE to CC0_license
2020-07-17 cco license for docs
2020-07-18 test all pins
2020-07-20 pinout
2020-07-20 test can get a bitfile for all pins on 12,25 and 45k variants
2020-07-20 ignore for the test
2020-07-20 ignore auto fab dir
2020-07-20 ready to order
2020-07-20 osh park order
2020-07-20 fix a couple of off centre vias in bga
2020-07-20 added input R for dc/dc
2020-07-20 osh park gerbers
2020-07-20 part numbers and notes on dc/dc voltage dividers
2020-07-20 ignore logs, make device a variable
2020-07-20 updated pinning, part numbers and test
2020-07-20 fixlink
2020-07-20 fix link
2020-07-20 extra comment on spi pin
2020-07-20 test link
2020-07-22 fix wrong package version of switcher chip
2020-07-28 add oshw link
2020-07-28 oshw mark
2020-07-28 oshw logo
2020-07-28 inductor 3d and new board pic
2020-08-03 fix makefile and flash pmods in sequence for short detection
2020-08-03 change render for photo
2020-08-03 typo
2020-08-03 add pull down config bit
2020-08-03 link to ice40 version
2020-08-04 remove old rules
2020-08-04 cleanup config silkscreen
2020-08-04 removed unneeded pullup for PG pin on buck converters
2020-08-07 change 10k i2c pullups to 4k7
2020-08-07 remove a few stubs on copper fpga supply. improve silk
2020-08-07 date
2020-08-07 RPi gotchas
2020-08-07 link and formatting
2020-08-07 neaten FPGA page
2020-08-07 neatened schematic
2020-08-11 updated to use icebreaker flash as it works easily for QE
2020-08-13 add attribution for kicad ecp5 libary symbols
2020-11-03 fixed some problems in the makefile, added compress option for faster programming
2020-11-03 comment on 12k test
2020-11-03 notes on spi clock issue
2020-11-04 demo for spi clk in bodge
2020-11-04 note on workaround
2020-11-05 fix .bit instead of .bin
2020-12-05 note on leds and picosoc
2021-07-17 * Add missing qspi to the Pi to be able to program bitstream faster. Done
    * used IS25LP016D-JBLE as flash, but
    it has problems with enabling QE for QSPI.
    Relace with the model used on icebreaker
    This is already done, comment should be removed
    * ecp5 SPI clock pin can't be used as an input
    so have to [add a bodge wire](https://github.com/mattvenn/basic-ecp5-pcb/issues/3)
2021-07-17 added not tracking rescue
